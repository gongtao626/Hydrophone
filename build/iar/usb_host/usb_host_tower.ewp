# IAR project usb_host_tower.ewp, settings and files
configuration FLASH_128KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K20D50M
  ICCARM.CCIncludePath2: ..\..\..\src\projects\usb_host; ..\..\..\src\projects\usb_host\bsp; ..\..\..\src\projects\usb_host\classes\common; ..\..\..\src\projects\usb_host\classes\hid; ..\..\..\src\projects\usb_host\classes\hub; ..\..\..\src\projects\usb_host\common; ..\..\..\src\projects\usb_host\driver; ..\..\..\src\projects\usb_host\host_common; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\lptmr; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: usb_host_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_usb.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB_PFLASH_32KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_32KB_Dflash_usb.icf
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\src\projects\usb_host; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\projects\usb_host; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: hello_world_tower.srec
  ILINK.IlinkIcfFile: ..\config files\16KB_RAM.icf
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h mcg_ram.c mcg_ram.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_32KB_Dflash.icf 16KB_RAM.icf 32KB_Pflash.icf 32KB_Pflash_32KB_Dflash.icf 64KB_Pflash.icf 64KB_Pflash_32KB_Dflash.icf 8KB_RAM.icf
    ../: iar.h
  group project
    ../../../src/projects/usb_host/: hidmouse.c hidmouse.h isr.h tower.h
  group project/bsp
    ../../../src/projects/usb_host/bsp/: bsp_K20.c bsp_K20.h MK20.c
  group project/classes
    ../../../src/projects/usb_host/classes/common/: usb_classes.c usb_classes.h
    ../../../src/projects/usb_host/classes/hid/: usb_host_hid.c usb_host_hid.h
    ../../../src/projects/usb_host/classes/hub/: usb_host_hub.c usb_host_hub.h usb_host_hub_prv.h usb_host_hub_sm.c usb_host_hub_sm.h
  group project/common
    ../../../src/projects/usb_host/common/: common.h rtc.c rtc.h startup.c startup.h
  group project/driver
    ../../../src/projects/usb_host/driver/: khci.c khci.h psptypes.h types.h usb.h usb_bsp.h usb_desc.h usbevent.c usbevent.h usbmsgq.c usbmsgq.h usbprv.h usbprv_host.h usbsem.c usbsem.h
  group project/host_common
    ../../../src/projects/usb_host/host_common/: host_ch9.c host_ch9.h host_close.c host_close.h host_cnfg.h host_cnl.c host_cnl.h host_common.c host_common.h host_debug.h host_dev_list.c host_dev_list.h host_driver.c host_driver.h host_main.c host_main.h host_rcv.c host_rcv.h host_shut.c host_shut.h host_snd.c host_snd.h hostapi.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
