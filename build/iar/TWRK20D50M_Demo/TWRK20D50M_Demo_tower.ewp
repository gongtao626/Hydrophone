# IAR project TWRK20D50M_Demo_tower.ewp, settings and files
configuration FLASH_128KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K20D50M
  ICCARM.CCIncludePath2: ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\lptmr; ..\..\..\src\platforms; ..\; ..\..\..\src\projects\TWRK20D50M_Demo; ..\..\..\src\projects\TWRK20D50M_Demo\dma; ..\..\..\src\projects\TWRK20D50M_Demo\adc16; ..\..\..\src\projects\TWRK20D50M_Demo\i2c; ..\..\..\src\projects\TWRK20D50M_Demo\tsi; ..\..\..\src\projects\TWRK20D50M_Demo\adc_test; ..\..\..\src\projects\TWRK20D50M_Demo\angle_calculation; ..\..\..\src\projects\TWRK20D50M_Demo\buzzer; ..\..\..\src\projects\TWRK20D50M_Demo\fft_test; ..\..\..\src\projects\TWRK20D50M_Demo\irda_test; ..\..\..\src\projects\TWRK20D50M_Demo\cmt_test; ..\..\..\src\projects\TWRK20D50M_Demo\protocol; ..\..\..\src\projects\TWRK20D50M_Demo\task_mgr; ..\..\..\src\projects\TWRK20D50M_Demo\TWRK20_specific; ..\..\..\src\projects\TWRK20D50M_Demo\rtc; ..\..\..\src\CMSIS\DSP_Lib\Lib\intermediateFiles; ..\..\..\src\CMSIS\DSP_Lib\Include; ..\..\..\src\CMSIS\CM4\DeviceSupport\ARM\ARMCM4; ..\..\..\src\CMSIS\CM4\CoreSupport; ..\..\..\src\CMSIS\CM4\CoreSupportLiker Options-Library; ..\..\..\src\CMSIS\DSP_Lib\Lib\intermediateFiles\arm_cortexM4_math.lib; ..\..\..\build
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TWRK20D50M_Demo_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB_PFLASH_32KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\src\projects\TWRK20D50M_Demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_32KB_Dflash.icf
configuration FLASH_64KB_PFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash.icf
configuration FLASH_64KB_PFLASH_32KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\64KB_Pflash_32KB_Dflash.icf
configuration FLASH_32KB_PFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash.icf
configuration FLASH_32KB_PFLASH_32KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\32KB_Pflash_32KB_Dflash.icf
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\src\projects\TWRK20D50M_Demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\projects\TWRK20D50M_Demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\16KB_RAM.icf
configuration RAM_8KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\8KB_RAM.icf
  group common
    ../../../src/common/: assert.c assert.h common.h io.c io.h memtest.c memtest.h startup.c startup.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h mcg_ram.c mcg_ram.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_32KB_Dflash.icf 16KB_RAM.icf 32KB_Pflash.icf 32KB_Pflash_32KB_Dflash.icf 64KB_Pflash.icf 64KB_Pflash_32KB_Dflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/TWRK20D50M_Demo/: isr.h TWRK20D50M_Demo.c
  group project/adc16
    ../../../src/projects/TWRK20D50M_Demo/adc16/: adc16.c adc16.h
  group project/adc_test
    ../../../src/projects/TWRK20D50M_Demo/adc_test/: adc_test.c adc_test.h
  group project/angle_calculation
    ../../../src/projects/TWRK20D50M_Demo/angle_calculation/: angle_cal.c angle_cal.h asin.c asin.h median.c median.h sqrt16.c sqrt16.h
  group project/buzzer
    ../../../src/projects/TWRK20D50M_Demo/buzzer/: buzzer.c buzzer.h
  group project/cmt_test
    ../../../src/projects/TWRK20D50M_Demo/cmt_test/: cmt_test.c cmt_test.h
  group project/fft_test
    ../../../src/projects/TWRK20D50M_Demo/fft_test/: fft_test.c fft_test.h
  group project/i2c
    ../../../src/projects/TWRK20D50M_Demo/I2C/: hal_dev_mma8451.c hal_dev_mma8451.h hal_i2c.c hal_i2c.h
  group project/irda_test
    ../../../src/projects/TWRK20D50M_Demo/irda_test/: irda_test.c irda_test.h
  group project/protocol
    ../../../src/projects/TWRK20D50M_Demo/protocol/: protocol.c protocol.h
  group project/rtc
    ../../../src/projects/TWRK20D50M_Demo/rtc/: rtc.c rtc.h
  group project/task_mgr
    ../../../src/projects/TWRK20D50M_Demo/task_mgr/: task_mgr.c task_mgr.h
  group project/tsi
    ../../../src/projects/TWRK20D50M_Demo/TSI/: tsi.c tsi.h
  group project/tsi_test
    ../../../src/projects/TWRK20D50M_Demo/tsi_test/: tsi_test.c
  group project/TWRK20_specific
    ../../../src/projects/TWRK20D50M_Demo/TWRK20_specific/: TWR_K20D50M_DEF.c TWR_K20D50M_DEF.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
