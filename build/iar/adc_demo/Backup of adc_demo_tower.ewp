# IAR project Backup of adc_demo_tower.ewp, settings and files
configuration FLASH_128KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MK20DX128xxx5 Freescale MK20DX128xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER; TWR_K20D50M
  ICCARM.CCIncludePath2: ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\drivers\adc16; ..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_demo_tower.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_128KB_PFLASH_32KB_DFLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: platinum_tower.srec
  ILINK.IlinkIcfFile: ..\config files\128KB_Pflash_32KB_Dflash.icf
configuration RAM_16KB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\projects\adc_demo; ..\..\..\src\common; ..\..\..\src\cpu; ..\..\..\src\cpu\headers; ..\..\..\src\drivers\uart; ..\..\..\src\drivers\mcg; ..\..\..\src\drivers\wdog; ..\..\..\src\drivers\rcm; ..\..\..\src\drivers\rtc; ..\..\..\src\drivers\smc; ..\..\..\src\drivers\llwu; ..\..\..\src\drivers\lptmr; ..\..\..\src\drivers\pmc; ..\..\..\src\platforms; ..\
  OBJCOPY.OOCOutputFile: hello_world_tower.srec
  ILINK.IlinkIcfFile: ..\config files\16KB_RAM.icf
  group common
    ../../../src/common/: assert.c assert.h common.h io.c io.h memtest.c memtest.h startup.c startup.h uif.c uif.h
  group cpu
    ../../../src/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group drivers/adc16
    ../../../src/drivers/adc16/: adc16.c adc16.h
  group drivers/llwu
    ../../../src/drivers/llwu/: llwu.c llwu.h
  group drivers/lptmr
    ../../../src/drivers/lptmr/: lptmr.c lptmr.h
  group drivers/mcg
    ../../../src/drivers/mcg/: mcg.c mcg.h mcg_ram.c mcg_ram.h
  group drivers/pmc
    ../../../src/drivers/pmc/: pmc.c pmc.h
  group drivers/rcm
    ../../../src/drivers/rcm/: rcm.c rcm.h
  group drivers/rtc
    ../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/smc
    ../../../src/drivers/smc/: smc.c smc.h
  group drivers/uart
    ../../../src/drivers/uart/: uart.c uart.h
  group drivers/wdog
    ../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: 128KB_Pflash.icf 128KB_Pflash_32KB_Dflash.icf 16KB_RAM.icf 32KB_Pflash.icf 32KB_Pflash_32KB_Dflash.icf 64KB_Pflash.icf 64KB_Pflash_32KB_Dflash.icf 8KB_RAM.icf
    ../: iar.h
  group platforms
    ../../../src/platforms/: tower.h
  group project
    ../../../src/projects/adc_demo/: adc_demo.c adc_demo.h dsp.h dsp.s hw_trig_test.c hw_trig_test.h isr.h
  group semihosting
    ../../../src/semihosting/iar/: read.c write.c
